## Kconfig
```kconfig
config USR_DRV_AD7843
  bool  "userspace AD7843 driver"
  default y
  ---help---
  Support for AD7843 hardware Touch.
```
